options:
  parameters:
    generate_options: qt_gui
    id: cuava_receiver
    output_language: python
    title: CUAVA beacon receiver
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: baud_rate*200
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: costas_loop
  id: variable_qtgui_range
  parameters:
    label: costas_loop
    start: '0'
    step: '0.001'
    stop: '1'
    value: math.pi/10
  states: {}
- name: max_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: rrc_bw
  id: variable_qtgui_range
  parameters:
    label: rrc_bw
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.35'
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: rrc_bw
    gain: '1'
    ntaps: '2000'
    samp_rate: samp_rate
    sym_rate: baud_rate*2
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '400650000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 800*baud_rate
  states: {}
- name: symbol_sync_loop
  id: variable_qtgui_range
  parameters:
    label: symbol_sync_loop
    start: '0'
    step: '0.001'
    stop: '1'
    value: math.pi/10
  states: {}
- name: usrp_gain
  id: variable_qtgui_range
  parameters:
    comment: 15 if only RX connected
    start: '0'
    step: '1'
    stop: '80'
    value: '27'
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: max_gain
    rate: '1'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cuava/Groundstation/groundstation/groundstation-tools/flowgraphs/file-sink.txt
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/cuava/beacon.raw
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1000'
    port: '3210'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: symbol_sync_loop
    max_dev: '0.05'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: rrc_filter_taps
    resamp_type: digital.IR_PFB_NO_MF
    sps: '10'
    ted_gain: '1'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '80'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    color1: red
    size: int(samp_rate/100)
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: rx_freq
    dev_addr: ''
    dev_args: '""'
    gain0: usrp_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_1, '0', digital_symbol_sync_xx_1, '0']
- [analog_agc_xx_1, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_costas_loop_cc_0, '0', analog_agc_xx_1, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_1, '0']
- [low_pass_filter_0, '0', digital_costas_loop_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_hdlc_deframer_0, out, blocks_socket_pdu_0, pdus]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.6.0-1-gac58f3ba
